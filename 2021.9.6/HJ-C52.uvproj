# Keil uVision project HJ-C52.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: HJ-C52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源程序组 1
    ./: main.c delay.c hjc52.c
